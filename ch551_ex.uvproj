# Keil uVision project ch551_ex.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ch551_ex +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./GPIO/: GPIO.C GPIO.H
    ./Public/: Debug.C
    ./Timer/: Timer.C
